DEPENDS:append = " perl-native"
