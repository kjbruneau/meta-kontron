FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://mod_paths.patch"

