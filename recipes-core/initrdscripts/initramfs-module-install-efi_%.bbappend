FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0002-Add-resume-swap-partion-to-init-install-efi-script.patch \
            file://0003-Increase-spare-space-for-boot-to-256-MB.patch \
           "

