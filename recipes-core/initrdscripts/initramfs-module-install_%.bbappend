FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-Add-resume-swap-partion-to-init-install-script.patch"

