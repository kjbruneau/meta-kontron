RDEPENDS:${PN} += "\
        nativesdk-rpm \
        nativesdk-bzip2 \
        nativesdk-xz \
        "
