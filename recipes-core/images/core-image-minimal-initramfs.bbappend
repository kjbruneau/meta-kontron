PACKAGE_INSTALL:append = " efibootmgr kernel-module-efivars kernel-module-zram"
