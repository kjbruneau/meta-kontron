RDEPENDS_run-postinsts="bash"
