FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

PR = "r1"

SRC_URI += " file://0002-client-conf-Enable-autospawn-for-root.patch \
           "
